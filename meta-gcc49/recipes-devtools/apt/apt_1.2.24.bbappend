FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "\
	file://0001-Fix-for-gcc-49.patch\
	file://0002-Fix-put-time.patch\
	"
